# Keil uVision project LCD180C.uvprojx, settings and files
target STM32F4x1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD180C +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c include: ..\MDK-ARM;..\Core\Inc;..\Drivers\STM32F4xx_StdPeriph_Driver\inc;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Middlewares\delay;..\Middlewares\gpio;..\Middlewares\tim;..\Middlewares\usart;..\Middlewares\key;..\Middlewares\IWDG;..\Middlewares\GBK_LibDrive;..\Middlewares\LCD180C;..\Drivers\STM32F4xx_StdPeriph_Driver;..\Core\Src;..\Core\Src;..\Core\Inc;..\Core\Inc\Include;..\Middlewares\stm32f4_MLX90614;..\Middlewares\sys;..\Middlewares\delay;..\Middlewares\ULTRASONIC;..\Middlewares\WAVE;..\Middlewares\beep;..\Middlewares\SYN6288;..\Middlewares\DHT11;..\Middlewares\ADC;..\NET\cJSON;..\NET\device;..\NET\MQTT;..\NET\onenet;..\Middlewares\RTC;..\Middlewares\BH1750
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User/Core
    ../Core/Src/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group MDK-ARM
    ./: startup_stm32f401xx.s startup_stm32f411xe.s
  group Middlewares
    ../Middlewares/delay/: delay.c delay.h
    ../Middlewares/gpio/: gpio.c
    ../Middlewares/tim/: tim.c
    ../Middlewares/usart/: usart.c
    ../Middlewares/key/: key.c
    ../Middlewares/sys/: sys.c sys.h
    ../Middlewares/beep/: bsp_beep.c bsp_beep.h
    ../Middlewares/DHT11/: dht11.c
    ../Middlewares/ADC/: adc.c
    ../Middlewares/RTC/: rtc.c
    ../Middlewares/BH1750/: i2c_bh1750.c i2c_bh1750_gpio.c
  group Drivers/STM32F4xx_StdPeriph_Driver
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group LCD180
    ../Middlewares/GBK_LibDrive/: GBK_LibDrive.c
    ../Middlewares/LCD180C/: Dis_Picture.c FONT.c lcd.c Picture.c Text.c
  group net
    ../NET/cJSON/: cJSON.c
    ../NET/device/: esp8266.c
    ../NET/MQTT/: MqttKit.c
    ../NET/onenet/: onenet.c
